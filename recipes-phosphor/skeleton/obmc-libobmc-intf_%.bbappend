FILESEXTRAPATHS_prepend_gsj := "${THISDIR}/${PN}:"

SRC_URI_append_gsj = " file://0001-support-nuvoton-gpiochip.patch"
