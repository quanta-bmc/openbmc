FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-add-NVME-proproty-and-error-yaml.patch"
SRC_URI += "file://0002-Add-ECC-dbus-property.patch"


