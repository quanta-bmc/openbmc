FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://0001-libfdt-fix-libfdt-header-conflicts-between-UBoot-and.patch"