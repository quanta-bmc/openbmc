FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Update-period-to-d-bus-which-get-from-config.patch"
