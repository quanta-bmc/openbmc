SRCREV = "5b1417bd21d1e9c00b25bb6db700aec442af746d"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Get-parameter-period-in-yaml-config.patch"
