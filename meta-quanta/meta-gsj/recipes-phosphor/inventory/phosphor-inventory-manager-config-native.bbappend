PHOSPHOR_INVENTORY_MANAGER_CONFIGS += "phosphor-inventory-manager-nvme-native"

