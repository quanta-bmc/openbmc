DEPENDS_append = " inventory-nvme"
