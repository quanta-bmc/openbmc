FILESEXTRAPATHS_append_gsj := ":${THISDIR}/${PN}"
SRC_URI_append_gsj = " file://time-default.override.yml"
SRC_URI_append_gsj = " file://restrictionmode-default-whitelist.override.yml"
