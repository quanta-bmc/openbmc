NETIPMI_PROVIDER_LIBRARY += "libi2ccmds.so"
