NETIPMI_PROVIDER_LIBRARY += "libsyscmds.so"
